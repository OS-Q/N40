# Keil uVision project Platforms.uvprojx, settings and files
target Platforms (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Platforms +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c misc: --C99
  c include: ../Inc;..\Bootloader\Xmodem;C:/Users/qitas/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/STM32F0xx_HAL_Driver/Inc;C:/Users/qitas/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;C:/Users/qitas/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/CMSIS/Device/ST/STM32F0xx/Include;C:/Users/qitas/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Application/IAP
    ../Bootloader/Xmodem/: flash_if.c xmodem.c menu.c
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Drivers/STM32F0xx_HAL_Driver
    C:/Users/qitas/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
