# Keil uVision project Xmodem_client.uvprojx, settings and files
target Xmodem_client (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Xmodem_client
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: .\..\app\inc;.\..\Lib\STM32F1\inc;.\..\Lib\CM3\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./../app/src/: xmodem_client.c main.c uartdriver.c modbusrtuslave.c stm32f10x_it.c
  group stm32StdLib
    ./../Lib/STM32F1/src/: misc.c stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group startup
    ./../Lib/STARTUP/: startup_stm32f10x_cl.s
    ./../Lib/CM3/src/: core_cm3.c system_stm32f10x.c
